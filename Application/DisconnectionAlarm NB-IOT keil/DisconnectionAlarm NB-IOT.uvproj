# Keil uVision project DisconnectionAlarm NB-IOT.uvproj, settings and files
target CA51FX (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: ca51fx +hex
  c flags: Optimize=9
  group ca51f_config
    ./: ca51f_config.h
  group Source Files
    ./: main.c
    ../../Library/Sources/: system_clock.c delay.c uart.c pwm.c stop_idle.c rtc.c adc.c
    ../NB_iot/: Nb_iot.c
    ../Wirealarm/: Wirealarm.c
    ../drive/Sources/: voltage_adc.c
  group Lib
    ../../Library/Lib/: STARTUP.A51
